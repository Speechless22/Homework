# Keil uVision project 5-1.uvproj, settings and files
target 5-1 (MCS-51)
  device: AT89C52 Atmel
  output: 5-1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ../../../../../../Program Files/Keil_v5/C51/INC;src
  group SRC
    src/: main.c
