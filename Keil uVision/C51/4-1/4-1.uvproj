# Keil uVision project 4-1.uvproj, settings and files
target 4-1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 4-1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ../../../../../../Program Files/Keil_v5/C51/INC;src
  group SRC
    src/: main.c
